# Keil uVision project CAN.uvprojx, settings and files
target CAN (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CAN +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\RTC;..\HARDWARE\RTC;..\HARDWARE\WKUP;..\HARDWARE\ADC;..\HARDWARE\DAC;..\HARDWARE\DMA;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\HARDWARE\SPI;..\HARDWARE\FLASH;..\HARDWARE\TOUCH;..\HARDWARE\RS485;..\HARDWARE\CAN;..\USER;..\HARDWARE\PSTWO;..\SYSTEM\move;..\HARDWARE\RS485;..\HARDWARE\TIMER;..\SYSTEM\magc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
    ../SYSTEM/move/: drive.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/PSTWO/: pstwo.c
    ../HARDWARE/RS485/: rs485.c
    ../HARDWARE/TIMER/: timer.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ./: canopen.c system.c
    ../SYSTEM/magc/: magc.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_can.c stm32f10x_usart.c stm32f10x_tim.c
  group README
    ../: README.TXT
  group New Group
    ../SYSTEM/usart/: usart.h
    ../SYSTEM/sys/: sys.h
    ../SYSTEM/delay/: delay.h
    ../HARDWARE/PSTWO/: pstwo.h
    ../SYSTEM/move/: drive.h
    ../HARDWARE/RS485/: rs485.h
    ../SYSTEM/magc/: magc.h
    ../HARDWARE/TIMER/: timer.h
