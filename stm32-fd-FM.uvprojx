# Keil uVision project stm32-fd-FM.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32-FD-FM +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: .\FWlib\inc;.\user;.\CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group ASM
    ./startup/: startup_stm32f10x_hd.s
  group USR
    ./user/: stm32f10x_it.c main.c movebase.c system.c canopen.c crabdrive.c time.c
  group FWlib
    ./FWlib/SRC/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_fsmc.c stm32f10x_dma.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_tim.c
  group CMSYS
    ./CM3/: core_cm3.c system_stm32f10x.c
  group readme
    ./user/: readme.txt
  group ::Device
    RTE/Device/ARMCM4/: startup_ARMCM4.s system_ARMCM4.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.1
